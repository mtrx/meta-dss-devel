# need to update to git master

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://escape.patch"

PRINC="2"

