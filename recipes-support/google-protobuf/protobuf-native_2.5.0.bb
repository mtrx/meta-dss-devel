# Google protobuf
require protobuf.inc

PR = "r1"
SRC_URI[md5sum] = "a72001a9067a4c2c4e0e836d0f92ece4"
SRC_URI[sha256sum] = "13bfc5ae543cf3aa180ac2485c0bc89495e3ae711fc6fab4f8ffe90dfb4bb677"

inherit native
