PRINC = "1"

RDEPENDS_${PN} += "modutils-initscripts"

