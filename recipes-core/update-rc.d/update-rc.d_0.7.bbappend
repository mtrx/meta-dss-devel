#PRINC="1"
#
#RDEPENDS_${PN} = "sysvinit"
