PRINC = "1"

# do not put killall5 into the pidof package, breaks live update
FILES_sysvinit-pidof = "${base_bindir}/pidof.sysvinit"

