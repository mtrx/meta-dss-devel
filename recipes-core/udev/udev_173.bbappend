# replacing "default" file to disable device cache
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

PRCINC = "1"
