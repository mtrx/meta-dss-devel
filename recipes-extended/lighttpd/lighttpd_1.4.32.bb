require lighttpd.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "d2eaf2ed77670bd25597f61c3a28c074"
SRC_URI[sha256sum] = "0765e07dac432393dea3950639d5ba646ded95a9408ad002e54b3353ab6b9645"

