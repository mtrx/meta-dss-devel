include gsoap.inc

PR = "r1.${INC_PR}"

DEPENDS = "openssl-native"

inherit native

SRC_URI[md5sum] = "541dcff86d1c6171cb8540cf51a4cfa8"
SRC_URI[sha256sum] = "838b8adefdaa40afcacc6811a73d7bcc19ecf352728647afe72e4203cb512141"

